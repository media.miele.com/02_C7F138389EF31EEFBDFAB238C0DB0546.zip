Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 77513e0a-be8d-41b6-89a4-f6303ef59ca9, NumberOfSaves: 1]
File name: 0001
Time: 2025-02-27T11:56:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12532030_A_CM7750_OBSWMATT:29775021_A_12532030_CM7750_OBSWMATT, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 311 mm; Height: 420 mm; Depth: 445 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 29775021_A_12532030_CM7750_OBSWMATT; sets with these values: 2
